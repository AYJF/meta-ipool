# See sibling rkbin bbappends: new oe-core unpacks git to ${UNPACKDIR}/${BP}.
# The rkbin host tools live in the repo's tools/ subdir.
S = "${UNPACKDIR}/${BP}/tools"
